# IAR project bootloader-storage-internal-single-3200k.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG26B510F3200IM48 SiliconLaboratories EFR32MG26B510F3200IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: EFR32MG26B510F3200IM48=1; SL_CODE_COMPONENT_SYSTEM=system; SE_MANAGER_CONFIG_FILE="btl_aes_ctr_stream_block_cfg.h"; BOOTLOADER_ENABLE=1; BOOTLOADER_SECOND_STAGE=1; SL_RAMFUNC_DISABLE=1; __START=main; __STARTUP_CLEAR_BSS=1; SYSTEM_NO_STATIC_MEMORY=1; BOOTLOADER_SUPPORT_INTERNAL_STORAGE=1; BOOTLOADER_SUPPORT_STORAGE=1; HARDWARE_BOARD_DEFAULT_RF_BAND_2400=1; HARDWARE_BOARD_SUPPORTS_1_RF_BAND=1; HARDWARE_BOARD_SUPPORTS_RF_BAND_2400=1; HFXO_FREQ=39000000; SL_BOARD_NAME="BRD2709A"; SL_BOARD_REV="A03"; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_trustzone_config.h>; SL_CODE_COMPONENT_MEMORY_MANAGER=memory_manager; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_CODE_COMPONENT_SE_MANAGER=se_manager; SL_CODE_COMPONENT_CORE=core; SL_CODE_COMPONENT_PSEC_OSAL=psec_osal; SL_TRUSTZONE_SECURE=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse; --diag_suppress Pa082
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\devices\platform\Device\SiliconLabs\EFR32MG26\Include; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\platform_common\platform\common\inc; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\bootloader\platform\bootloader; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\bootloader\platform\bootloader\api; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\bootloader\platform\bootloader\debug; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\bootloader\platform\bootloader\parser; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\bootloader\platform\bootloader\core\flash; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\bootloader\platform\bootloader\security; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\cmsis\Core\Include; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\platform_core\platform\emlib\inc; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\platform_core\platform\common\errno_error_codes\inc; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_mbedtls\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_mbedtls\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_mbedtls_source\include; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_mbedtls\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_mbedtls_source\library; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\platform_core\platform\service\memory_manager\inc; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\platform_core\platform\service\memory_manager\src; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_mbedtls\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_se_manager\platform\security\sl_component\se_manager\inc; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\platform_core\platform\common\inc; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_tfm\lib\fih\inc; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_tfm\platform\include; ..\..\..\..\.silabs\slt\installs\conan\p\simpl35774a752829c\p\security_se_manager\platform\security\sl_component\sli_psec_osal\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bootloader-storage-internal-single-3200k.s37
  ILINK.IlinkOutputFile: bootloader-storage-internal-single-3200k.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: bootloader-storage-internal-single-3200k.ipcf
  group Simplicity Configurator
    ./: AGENTS.md
